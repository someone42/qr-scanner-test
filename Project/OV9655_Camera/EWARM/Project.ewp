# IAR project Project.ewp, settings and files
configuration Discover-More (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; NO_ICONV
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32F4-Discovery; ..\..\..\Utilities\FatFs_vR0.08a; ..\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group FatFs
    ../../../Utilities/FatFs_vR0.08a/: diskio.c ff.c
  group Readme
    ../: readme.txt
  group STM32F4-Discovery
    ../../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_lcd.c stm32f4_discovery_lis302dl.c stm32f4_discovery_sdio_sd.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group User
    ../src/: bmp.c dcmi_ov9655.c image.s main.c main_bridge.cpp stm32f4xx_it.c system_stm32f4xx.c
  group zxing
    ../src/zxing/: BarcodeFormat.cpp BarcodeFormat.h Binarizer.cpp Binarizer.h BinaryBitmap.cpp BinaryBitmap.h ChecksumException.cpp ChecksumException.h DecodeHints.cpp DecodeHints.h Exception.cpp Exception.h FormatException.cpp FormatException.h IllegalStateException.h LuminanceSource.cpp LuminanceSource.h MultiFormatReader.cpp MultiFormatReader.h NotFoundException.h Reader.cpp Reader.h ReaderException.h Result.cpp Result.h ResultIO.cpp ResultPoint.cpp ResultPoint.h ResultPointCallback.cpp ResultPointCallback.h ZXing.h
  group zxing/common
    ../src/zxing/common/: Array.h BitArray.cpp BitArray.h BitArrayIO.cpp BitMatrix.cpp BitMatrix.h BitSource.cpp BitSource.h CharacterSetECI.cpp CharacterSetECI.h Counted.h DecoderResult.cpp DecoderResult.h DetectorResult.cpp DetectorResult.h FastHybridBinarizer.cpp FastHybridBinarizer.h GlobalHistogramBinarizer.cpp GlobalHistogramBinarizer.h GridSampler.cpp GridSampler.h HybridBinarizer.cpp HybridBinarizer.h IllegalArgumentException.cpp IllegalArgumentException.h PerspectiveTransform.cpp PerspectiveTransform.h Point.h Str.cpp Str.h StringUtils.cpp StringUtils.h
  group zxing/common/detector
    ../src/zxing/common/detector/: MathUtils.h
  group zxing/common/reedsolomon
    ../src/zxing/common/reedsolomon/: GenericGF.cpp GenericGF.h GenericGFPoly.cpp GenericGFPoly.h ReedSolomonDecoder.cpp ReedSolomonDecoder.h ReedSolomonException.cpp ReedSolomonException.h
  group zxing/qrcode
    ../src/zxing/qrcode/: ErrorCorrectionLevel.cpp ErrorCorrectionLevel.h FormatInformation.cpp FormatInformation.h QRCodeReader.cpp QRCodeReader.h Version.cpp Version.h
  group zxing/qrcode/decoder
    ../src/zxing/qrcode/decoder/: BitMatrixParser.cpp BitMatrixParser.h DataBlock.cpp DataBlock.h DataMask.cpp DataMask.h DecodedBitStreamParser.cpp DecodedBitStreamParser.h Decoder.cpp Decoder.h Mode.cpp Mode.h
  group zxing/qrcode/detector
    ../src/zxing/qrcode/detector/: AlignmentPattern.cpp AlignmentPattern.h AlignmentPatternFinder.cpp AlignmentPatternFinder.h Detector.cpp Detector.h FinderPattern.cpp FinderPattern.h FinderPatternFinder.cpp FinderPatternFinder.h FinderPatternInfo.cpp FinderPatternInfo.h
